FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "???"
PR = "???"
