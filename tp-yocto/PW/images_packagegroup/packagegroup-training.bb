DESCRIPTION = "Package group for the training image"
LICENSE = "MIT"

inherit ???

RDEPENDS:${PN} = "???"
