# Base this image on core-image-minimal
# No package management !
include recipes-core/images/core-image-minimal.bb

IMAGE_INSTALL += "???"
