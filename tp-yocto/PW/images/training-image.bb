# Base this image on core-image-minimal
include recipes-core/images/???.bb

IMAGE_INSTALL += "???"

